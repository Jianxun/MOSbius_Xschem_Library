v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {Differential Pairs, 4x} -10 -160 0 0 0.4 0.4 {}
C {libs/MOSbius_v1/DP_nMOS_4x_A/DP_nMOS_4x_A.sym} 0 90 0 0 {name=x1}
C {libs/MOSbius_v1/DP_pMOS_4x_A/DP_pMOS_4x_A.sym} 0 -70 0 0 {name=x2}
C {libs/MOSbius_v1/DP_nMOS_4x_A/DP_nMOS_4x_A.sym} 120 90 0 0 {name=x3}
C {libs/MOSbius_v1/DP_pMOS_4x_A/DP_pMOS_4x_A.sym} 120 -70 0 0 {name=x4}
