v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {/foss/designs/libs/MOSbius_v1/DP_pMOS_4x_A/DP_pMOS_4x_A.sym} 0 0 0 0 {name=x1}
C {/foss/designs/libs/MOSbius_v1/DP_nMOS_4x_A/DP_nMOS_4x_A.sym} -80 0 0 0 {name=x2}
